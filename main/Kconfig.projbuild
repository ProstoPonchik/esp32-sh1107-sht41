## main/Kconfig.projbuild
```kconfig
menu "Example Configuration"

    config LV_FONT_JB_14
        bool "JetBrains 14"
        default y

endmenu
```
